# IAR project app_67.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: app_67.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\app; ..\..\Customer; ..\..\lib; ..\..\lib\sdk; ..\..\lib\gui; ..\..\lib\tls; ..\..\lib\gfs
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: app.bin
  postbuild: Build_ksp.bat
  ILINK.IlinkIcfFile: app.icf
  ILINK.IlinkProgramEntryLabel: __startup_appmain
  group app
    ../../app/: App_main.c app_net.c app_sdk.c dataconv.c drv_wifi.c EvenMsg.c FactoryMenu.c gbk2unicode.c ks_crypt.c TermParfile.c ui_display.c ui_menu.c
  group Customer
    ../: PE_customer.c PE_customer.h PE_sdk.c PE_SweepPay.c
